Commit message: feat: add intertia & mass

File: urdf/gripper.urdf (robot description, URDF)
Before this commit: robot shunk_gripper, 3 links, 2 joints
Links:
- link base_link: mass None -> 2.043549
- link finger_l: mass None -> 0.046237
- link finger_r: mass None -> 0.046237
